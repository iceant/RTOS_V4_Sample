# Keil uVision project RTOS_V4_Sample_GD32F303CGT6.uvprojx, settings and files
target GD32F303CGT6 (5050169::V5.05 update 2 (build 169)::ARMCC)
  device: GD32F303CG GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.3
  cpu: IRAM(0x20000000,0x018000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RTOS_V4_Sample_GD32F303CGT6 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F30X_XD,NDEBUG,HXTAL_VALUE=8000000
  c include: ..\..\..\RTOS_V4\Compiler\ARMCC;..\..\..\RTOS_V4\CPU;..\..\..\RTOS_V4\CPU\ARM-Cortex-M4;..\..\..\RTOS_V4\CPU\ARM-Cortex-M4\ARMCC;..\..\..\RTOS_V4\Kernel;..\..\..\RTOS_V4\SDK;..\..\..\RTOS_V4\Pub\TLSF-2.4.6\src;..\Board;..\Application;..\Firmware\GD32F30x_Firmware_Library_V2.2.0\Firmware\CMSIS;..\Firmware\GD32F30x_Firmware_Library_V2.2.0\Firmware\CMSIS\GD\GD32F30x\Include;..\Firmware\GD32F30x_Firmware_Library_V2.2.0\Firmware\GD32F30x_standard_peripheral\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group CMSIS
    ../Firmware/GD32F30x_Firmware_Library_V2.2.0/Firmware/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
    ../Firmware/GD32F30x_Firmware_Library_V2.2.0/Firmware/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_xd.s
  group FWLIB
    ../Firmware/GD32F30x_Firmware_Library_V2.2.0/Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group RTOS_COMPILER
    ../../../RTOS_V4/Compiler/ARMCC/: c_compiler.c
  group RTOS_CPU
    ../../../RTOS_V4/CPU/: cpu.c cpu_macros.c
    ../../../RTOS_V4/CPU/ARM-Cortex-M4/: cpu_atomic.c cpu_exception.c cpu_init.c cpu_lock.c cpu_options.c cpu_private.c cpu_special.c cpu_spinlock.c cpu_stack.c cpu_svc.c cpu_types.c
    ../../../RTOS_V4/CPU/ARM-Cortex-M4/ARMCC/: cpu_functions.c cpu_hardfault.c cpu_pendsv.c cpu_svc_handler.c
  group RTOS_Kernel
    ../../../RTOS_V4/Kernel/: os_definitions.c os_error.c os_idle.c os_interrupt.c os_kernel.c os_list.c os_lock.c os_macros.c os_memory.c os_mutex.c os_priority.c os_readylist.c os_scheduler.c os_sem.c os_service.c os_thread.c os_tick.c os_timer.c os_timewheel.c os_types.c os_waitobject.c
  group RTOS_SDK
    ../../../RTOS_V4/SDK/: md5.c sdk_ap.c sdk_bit.c sdk_crc16.c sdk_definition.c sdk_error.c sdk_fmt.c sdk_hex.c sdk_memory.c sdk_mp.c sdk_ring.c sdk_ringbuffer.c sdk_types.c sdk_vector.c sdk_xp.c
  group PUB_TLSF
    ../../../RTOS_V4/Pub/TLSF-2.4.6/src/: tlsf.c
  group Board
    ../Board/: board.c bsp_retarget.c bsp_usart1.c gd32f30x_it.c
  group Application
    ../Application/: main.c nvic_show_priority.c printf.c single_thread.c thread_exit.c two_yield_thread.c os_config.h
